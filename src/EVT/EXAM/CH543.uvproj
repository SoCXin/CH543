# Keil uVision project CH543.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH543 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: CH543 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ADC;.\Compare;.\FlashRom;.\GPIO;.\I2C;.\Public;.\PWM;.\SPI;.\TIMER;.\TouchKey;.\UART;.\USB\Host;.\USB\USB_LIB;.\PD;.\PD\PD PHY;.\PD_PROT
  group pub
    ./Public/: DEBUG.C
